# Keil uVision project Lora.uvprojx, settings and files
target HW1.0-AS923 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\AS923\HW1.0\Lora.hex .\outputs\AS923_HW1.0.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_AS923, HW_1_0, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: inc;Drivers\BSP\MLM32L07X01;Drivers\STM32L0xx_HAL_Driver\Inc;Drivers\CMSIS\Device\ST\STM32L0xx\Include;Drivers\CMSIS\Include;Middlewares\Third_Party\Lora\Crypto;Middlewares\Third_Party\Lora\Mac;Middlewares\Third_Party\Lora\Phy;Middlewares\Third_Party\Lora\Utilities;Drivers\BSP\X_NUCLEO_IKS01A1;Middlewares\Third_Party\Lora\Core;Drivers\BSP\Components\Common;Drivers\BSP\Components\hts221;Drivers\BSP\Components\lps22hb;Drivers\BSP\Components\lps25hb;Drivers\BSP\Components\sx1276;Drivers\BSP\B-L072Z-LRWAN1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ./: readme.txt
  group Drivers/BSP/Components
    Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/MLM32L0X01
    Drivers/BSP/MLM32L07X01/: mlm32l07x01.c
  group Drivers/CMSIS
    Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_adc.c stm32l0xx_ll_gpio.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_ll_dma.c
  group Projects/MDK-ARM
    ./: startup_stm32l072xx.s
  group Headers
    ./inc/: at.h Commissioning.h debug.h debug_uart.h hw.h hw_conf.h hw_gpio.h hw_msp.h hw_rtc.h hw_spi.h lora.h mlm32l0xx_hw_conf.h mlm32l0xx_it.h stm32l0xx_hal_conf.h test_rf.h tiny_sscanf.h tiny_vsnprintf.h utilities_conf.h vcom.h version.h i2c1.h i2cFlash.h sht20.h _i2c1.h modbus_uart.h _modbus_uart.h _debug_uart.h lora_sensum.h modbus_generic.h counter.h flash_map.h global.h watchdog.h _watchdog.h delays.h uart_soil_probe.h adc.h pins.h sht30.h i2cCO2.h _conf_bits.h conf_bits.h ds18b20.h onewire.h _sigfox_uart.h sigfox_uart.h sigfox_sensum.h modbus_scl61d5.h packets.h radio_common.h 2I2O.h pins_1_0.h pins_1_1.h pins_1_2.h pins_1_3.h i2cLightSensor.h
  group Projects/AT_Slave
    src/: hw_spi.c at.c debug.c hw_gpio.c hw_rtc.c lora.c main.c tiny_sscanf.c tiny_vsnprintf.c vcom.c mlm32l0xx_hw.c mlm32l0xx_it.c test_rf.c
    ./src/: debug_uart.c i2c1.c i2cFlash.c sht20.c modbus_uart.c lora_sensum.c modbus_generic.c counter.c flash_map.c watchdog.c delays.c uart_soil_probe.c adc.c sht30.c i2cCO2.c i2cCO2_legacy.c conf_bits.c ds18b20.c onewire.c sigfox_uart.c sigfox_sensum.c modbus_scl61d5.c radio_common.c 2I2O.c i2cLightSensor.c
  group Middlewares/Lora/Mac
    Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
    Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
    Middlewares/Third_Party/Lora/Core/: lora-test.c
  group Middlewares/Lora/Utilities
    Middlewares/Third_Party/Lora/Utilities/: delay.c timeServer.c utilities.c low_power_manager.c
  group Middlewares/Lora/Crypto
    Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
  group SHELL
    ./SHELL/: shell.c shell.h UsartShell.c UsartShell.h shell_interface.h app_cli.c app_cli.h cli_led.c cli_led.h
target HW1.0-EU868 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\EU868\HW1.0\Lora.hex .\outputs\EU868_HW1.0.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_EU868, HW_1_0, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.0-US915 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\US915\HW1.0\Lora.hex .\outputs\US915_HW1.0.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_US915, HW_1_0, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.1-AS923 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\AS923\HW1.1\Lora.hex .\outputs\AS923_HW1.1.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_AS923, HW_1_1, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.1-EU868 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\EU868\HW1.1\Lora.hex .\outputs\EU868_HW1.1.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_EU868, HW_1_1, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.1-US915 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\US915\HW1.1\Lora.hex .\outputs\US915_HW1.1.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_US915, HW_1_1, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.2-SIGFOX (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\SIGFOX\HW1.2\Lora.hex .\outputs\SIGFOX_HW1.2.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, HW_1_2, RADIO_SIGFOX_AT
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.3-AS923 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\AS923\HW1.3\Lora.hex .\outputs\AS923_HW1.3.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_AS923, HW_1_3, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.3-EU868 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\EU868\HW1.3\Lora.hex .\outputs\EU868_HW1.3.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_EU868, HW_1_3, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.3-US915 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\US915\HW1.3\Lora.hex .\outputs\US915_HW1.3.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_US915, HW_1_3, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.3-SIGFOX (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\SIGFOX\HW1.3\Lora.hex .\outputs\SIGFOX_HW1.3.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, HW_1_3, RADIO_SIGFOX_AT
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.0-AU915 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\AU915\HW1.0\Lora.hex .\outputs\AU915_HW1.0.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_AU915, HW_1_0, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.1-AU915 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\AU915\HW1.1\Lora.hex .\outputs\AU915_HW1.1.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_AU915, HW_1_1, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target HW1.3-AU915 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Lora +hex
  AfterMake: cmd.exe /C "copy .\build\AU915\HW1.3\Lora.hex .\outputs\AU915_HW1.3.hex /Y"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx, USE_B_L072Z_LRWAN1, USE_FULL_LL_DRIVER, REGION_AU915, HW_1_3, RAIDO_LORA_INTERNAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
